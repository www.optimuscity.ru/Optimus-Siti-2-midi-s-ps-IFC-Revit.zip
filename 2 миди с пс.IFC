Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 2 миди с пс.IFC
Time: 2025-11-26T10:11:48
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2 миди.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[531]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[605]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[606]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[607]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[608]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[609]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[610]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[611]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[612]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[613]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[614]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[615]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[616]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[617]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[618]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[619]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[620]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[621]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[622]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[623]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[624]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[625]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[626]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[627]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[628]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[629]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[630]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[631]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[632]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[633]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[634]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[635]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[636]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[637]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[638]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[639]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[640]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[641]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[642]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[643]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[644]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[645]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[646]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[647]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[648]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[649]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[650]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[651]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[652]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[653]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[654]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[655]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[656]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[657]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[658]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[659]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[660]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[661]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[662]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[663]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[664]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2 миди.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
